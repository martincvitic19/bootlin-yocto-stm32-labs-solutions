FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://joystick-support.patch"

